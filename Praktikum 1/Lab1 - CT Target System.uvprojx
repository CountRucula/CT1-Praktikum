# Keil uVision project Lab1 - CT Target System.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: CT_Board_HS14_M4 STMicroelectronics
  pack: InES.CTBoard14_DFP.4.0.4
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Praktikum_1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress 6314
  group Source Group 1
    ./app/: utils_ctboard.c utils_ctboard.h main.c
